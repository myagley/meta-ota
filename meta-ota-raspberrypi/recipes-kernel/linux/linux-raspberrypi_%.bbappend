CMDLINE_remove = "root=/dev/mmcblk0p2"
CMDLINE_append = " root=\${ota_kernel_root}"

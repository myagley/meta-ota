FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI += " file://0001-Update-default-environment-for-updates.patch"
